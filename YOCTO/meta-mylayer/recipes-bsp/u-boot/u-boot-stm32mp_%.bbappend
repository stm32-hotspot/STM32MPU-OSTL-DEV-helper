FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-Load-kernel-from-rootfs.patch \
    file://0002-v2023.10-stm32mp-r1-rc8.patch \
    "

